options:
  parameters:
    author: aausat
    generate_options: no_gui
    id: satellite_sniffer
    output_language: python
    title: satellite_sniffer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(250e3)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * timeout)
    type: complex
  states: {}
- name: freq
  id: parameter
  parameters:
    short_id: f
    type: intx
    value: int(437e6)
  states: {}
- name: path
  id: parameter
  parameters:
    short_id: p
    type: str
    value: '""'
  states: {}
- name: timeout
  id: parameter
  parameters:
    type: intx
    value: '1800'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '60'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
